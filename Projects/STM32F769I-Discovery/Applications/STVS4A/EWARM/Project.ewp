# IAR project Project.ewp, settings and files
configuration STVS4A_BSP_LWIP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: AVS_USE_QSPI_FLASHED; AVS_USE_DEBUG; STM32F7; STM32F769xx; USE_HAL_DRIVER; USE_STM32F769I_DISCO; USE_STM32769I_DISCOVERY; xUSE_TRACEALYZER; xDATA_IN_ExtSDRAM; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; HAVE_STDINT_H; __FPU_PRESENT
  ICCARM.IExtraOptions: --diag_suppress  Pe177; --diag_suppress  Pa039; --diag_suppress  Pe550; --diag_suppress  Pe111; --diag_suppress  Go005; --diag_suppress  Go004; --diag_suppress  Pa082; --diag_suppress  Pa130
  ICCARM.CCIncludePath2: ..\Inc; ..\Config; ..\..\..\..\..\Middlewares\ST\STVS4A\Src; ..\..\..\..\..\Middlewares\ST\STVS4A\Inc; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Inc; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Assets; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Src\usb_audio_in; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32f7xx\Include; ..\..\..\..\..\Drivers\BSP; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\STM32F769I-Discovery; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Middlewares\Third_Party\Jansson; ..\..\..\..\..\Middlewares\Third_Party\HTTP2_LWIP\Inc; ..\..\..\..\..\Middlewares\Third_Party\HTTP2_LWIP\Inc\private; ..\..\..\..\..\Middlewares\Third_Party\HTTP2_LWIP\Config; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Codecs\SpiritDSP_MP3_Dec\inc; ..\..\..\..\..\Drivers\BSP\Components\wm8994; ..\..\..\..\..\Utilities\TraceRecorder\include; ..\..\..\..\..\Utilities\TraceRecorder\config; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\Middlewares\Third_Party\LWIP\src\include; ..\..\..\..\..\Middlewares\Third_Party\LWIP\system; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\Network\LwIP\Config; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\Network\LwIP; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\stm32F7xx\Bsp; ..\..\..\..\..\Middlewares\Third_Party\audio_modules\recognition\DNN\Include; ..\..\..\..\..\Middlewares\Third_Party\audio_modules\recognition\KWS; ..\..\..\..\..\Middlewares\Third_Party\wav; ..\..\..\..\..\Middlewares\Third_Party\ff13b\source; ..\..\..\..\..\Middlewares\Third_Party\fatfs_disk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\config
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM32_AVSdemo_F769.out
  ILINK.IlinkIcfFile: stm32f769xx_flash.icf
  ILINK.IlinkExtraOptions: --threaded_lib; --diag_suppress Lt009
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STVS4A_BSP_LWIP_TRACEANALYSER (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: AVS_USE_QSPI_FLASHED; AVS_HOOK_TRACE_ORYX; AVS_USE_DEBUG; STM32F7; STM32F769xx; USE_HAL_DRIVER; USE_STM32F769I_DISCO; USE_STM32769I_DISCOVERY; USE_TRACEALYZER; xDATA_IN_ExtSDRAM; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; HAVE_STDINT_H
  ICCARM.CCIncludePath2: ..\Inc; ..\Config; ..\..\..\..\..\Middlewares\ST\STVS4A\Src; ..\..\..\..\..\Middlewares\ST\STVS4A\Inc; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Inc; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Assets; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Src\usb_audio_in; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32f7xx\Include; ..\..\..\..\..\Drivers\BSP; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\STM32F769I-Discovery; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Middlewares\Third_Party\Jansson; ..\..\..\..\..\Middlewares\Third_Party\HTTP2_LWIP\Inc; ..\..\..\..\..\Middlewares\Third_Party\HTTP2_LWIP\Config; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Codecs\SpiritDSP_MP3_Dec\inc; ..\..\..\..\..\Drivers\BSP\Components\wm8994; ..\..\..\..\..\Utilities\TraceRecorder\include; ..\..\..\..\..\Utilities\TraceRecorder\config; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\Middlewares\Third_Party\LWIP\src\include; ..\..\..\..\..\Middlewares\Third_Party\LWIP\system; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\Network\LwIP\Config; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\Network\LwIP; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\stm32F7xx\Bsp
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkExtraOptions: --threaded_lib; --diag_suppress  Lt009
configuration STVS4A_BSP_LWIP_DELIVERY (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: AVS_HOOK_TRACE_ORYX; NO_AVS_USE_DEBUG; NO_AVS_USE_TRACE_MEMORY; STM32F7; STM32F769xx; USE_HAL_DRIVER; USE_STM32F769I_DISCO; USE_STM32769I_DISCOVERY; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; HAVE_STDINT_H
  ICCARM.PreInclude: deliveryConfig.h
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkExtraOptions: --threaded_lib; --diag_suppress  Lt009
configuration STVS4A_BSP_LWIP_ESP (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CHECKSUM_BY_SOFTWARE; AVS_USE_QSPI_FLASHED; AVS_USE_DEBUG; STM32F7; STM32F769xx; USE_HAL_DRIVER; USE_STM32F769I_DISCO; USE_STM32769I_DISCOVERY; xUSE_TRACEALYZER; xDATA_IN_ExtSDRAM; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; HAVE_STDINT_H
  ICCARM.CCIncludePath2: ..\Inc; ..\Config; ..\..\..\..\..\Middlewares\ST\STVS4A\Src; ..\..\..\..\..\Middlewares\ST\STVS4A\Inc; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Inc; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Assets; ..\..\..\..\..\Middlewares\ST\STVS4A\Examples\Src\usb_audio_in; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32f7xx\Include; ..\..\..\..\..\Drivers\BSP; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\STM32F769I-Discovery; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Middlewares\Third_Party\Jansson; ..\..\..\..\..\Middlewares\Third_Party\HTTP2_LWIP\Inc; ..\..\..\..\..\Middlewares\Third_Party\HTTP2_LWIP\Inc\private; ..\..\..\..\..\Middlewares\Third_Party\HTTP2_LWIP\Config; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Codecs\SpiritDSP_MP3_Dec\inc; ..\..\..\..\..\Drivers\BSP\Components\wm8994; ..\..\..\..\..\Utilities\TraceRecorder\include; ..\..\..\..\..\Utilities\TraceRecorder\config; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\Middlewares\Third_Party\LWIP\src\include; ..\..\..\..\..\Middlewares\Third_Party\LWIP\system; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\Network\LWIP_esp\Config; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\Network\LWIP_esp; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\stm32F7xx\Bsp; ..\..\..\..\..\Middlewares\ST\STVS4A\Src\Porting\stm32F7xx
  ILINK.IlinkExtraOptions: --diag_suppress Lt009; --threaded_lib
configuration STVS4A_BSP_LWIP_ESP_DELIVERY (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CHECKSUM_BY_SOFTWARE; STM32F7; STM32F769xx; USE_HAL_DRIVER; USE_STM32F769I_DISCO; USE_STM32769I_DISCOVERY; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; HAVE_STDINT_H
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkExtraOptions: --diag_suppress Lt009; --threaded_lib
  group Application/Config
    ../Config/: assetConfig.h deliveryConfig.h
  group Application/Config/FreeRTOS
    ../Config/: FreeRTOSConfig.h trcConfig.h trcSnapshotConfig.h
  group Application/EWARM
    ./: startup_stm32f769xx.s stm32f769xx_flash.icf
  group Application/Inc
    ../Inc/: deliveryConfig.h platform_init.h stm32f7xx_it.h
  group Application/Src
    ../Src/: clean_lcd_swap_buffer.c esp_uart_conf.c ethernetif.c main.c platform_adapt.c platform_init.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c system_stm32f7xx.c usbd_conf_f7.c
  group Application/Src/Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM327F769I_Discovery
    ../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_audio.c stm32f769i_discovery_eeprom.c stm32f769i_discovery_lcd.c stm32f769i_discovery_qspi.c stm32f769i_discovery_sd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7XX_HAL_DRIVER/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/MP3_Decoder
    ../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/lib/: lib_mp3decoder_cortex_m7_v2.1.0.a
  group Middlewares/ST/STVS4A/Examples/Inc
    ../../../../../Middlewares/ST/STVS4A/Examples/Inc/: service.h service_alarm.h service_authentication.h service_endurance_test.h service_gui.h service_persistent_storage.h service_player.h service_state.h service_wakeup.h
  group Middlewares/ST/STVS4A/Examples/Services
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Services/: service_assets.c service_audio_feed_usb.c service_authentication.c service_os.c service_persistent_storage.c service_serial_trace.c
    ../../../../../MIDDLEWARES/ST/STVS4A/Examples/Src/Services/: service_wakeup.c
  group Middlewares/ST/STVS4A/Examples/Services/AudioPlayer
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Services/: service_alarm.c service_audio_play_mp3.c service_audio_read_fs.c service_audio_read_https.c service_player.c
  group Middlewares/ST/STVS4A/Examples/Services/Gui
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Services/: service_gui_core.c service_gui_page_info.c service_gui_page_language.c service_gui_page_test.c service_gui_resource_800_480.c
  group Middlewares/ST/STVS4A/Examples/Services/Gui/Wifi
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Services/: service_gui_page_wifi.c service_gui_page_wifi_flash_esp.c
  group Middlewares/ST/STVS4A/Examples/Services/Tests
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Tests/: service_endurance_definition.c service_endurance_test.c
  group Middlewares/ST/STVS4A/Examples/Services/Tests/UnitTest
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Tests/: service_test_check_player.c service_test_delay.c service_test_disconnection.c service_test_sequence.c service_test_wakeup.c
  group Middlewares/ST/STVS4A/Examples/Usb_audio_in
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/: avs.c
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/usb_audio_in/: usbd_audio_ex.c usbd_audio_in.c usbd_desc.c
  group Middlewares/ST/STVS4A/Inc
    ../../../../../Middlewares/ST/STVS4A/Inc/: avs.h avs_base.h avs_misra.h
  group Middlewares/ST/STVS4A/Src
    ../../../../../MIDDLEWARES/ST/STVS4A/Src/: avs_audio_imp.c avs_core_imp.c avs_http2_imp.c avs_kws_imp.c avs_sdk_entry_imp.c avs_state_imp.c avs_token_imp.c
    ../../../../../Middlewares/ST/STVS4A/Src/: avs_directive_imp.c avs_json_formater_imp.c avs_mem_imp.c
  group Middlewares/ST/STVS4A/Src/Porting
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/: avs_porting_imp.c
    ../../../../../Middlewares/ST/STVS4A/Inc/: avs_private.h
  group Middlewares/ST/STVS4A/Src/Porting/common
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Common/: avs_compiler_support.c avs_spirit_mp3_decoder_imp.c avs_sys_rng.c
  group Middlewares/ST/STVS4A/Src/Porting/Network/LWIP
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LWIP/: avs_lwip_drv_network.c avs_lwip_net_sockets.c avs_lwip_network_imp.c avs_lwip_porting_imp.c avs_lwip_tls_imp.c
  group Middlewares/ST/STVS4A/Src/Porting/Network/LWIP/Config
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LWIP/: avs_network.h avs_network_private.h network.h threading_alt.h
    ../../../../../Middlewares/ST/STVS4A/src/porting/network/LwIP/Config/: http2_client_config.h http2_debug.h
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LWIP/Config/: jansson_config.h
  group Middlewares/ST/STVS4A/Src/Porting/Network/LWIP_esp
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LWIP_esp/: avs_lwip_drv_network.c avs_lwip_net_sockets.c avs_lwip_network_imp.c avs_lwip_porting_imp.c avs_lwip_tls_imp.c avs_network.h avs_network_private.h avs_wifi_private.h network.h threading_alt.h
  group Middlewares/ST/STVS4A/Src/Porting/Network/LWIP_esp/Config
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LWIP_esp/Config/: jansson_config.h
  group Middlewares/ST/STVS4A/Src/Porting/Network/LWIP_esp/espDrv
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LWIP_esp/espDrv/: espDrvComUart.c espDrvCore.c espDrvCore.h espDrvEvents.c espDrvGlueAvs.c espDrvGlueAvs.h espDrvNetif.c espDrvOS.c espDrvOS.h espDrvProtocol.h
  group Middlewares/ST/STVS4A/Src/Porting/stm32f7xx
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/stm32F7xx/: avs_board_f7.h
  group Middlewares/ST/STVS4A/Src/Porting/stm32f7xx/bsp
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/stm32F7xx/Bsp/: avs_porting.h avs_porting_bsp_F7.h avs_porting_bsp_F7_audio.c avs_porting_bsp_F7_sys.c
    ../../../../../MIDDLEWARES/ST/STVS4A/Src/Porting/STM32F7XX/Bsp/: avs_porting_bsp_F7.c avs_porting_bsp_F7_audio_imp.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/Third_Party/audio_modules/recognition/DNN
    ../../../../../MIDDLEWARES/THIRD_PARTY/AUDIO_MODULES/RECOGNITION/DNN/: dnn.c dnn.h dnn_weights.h
    ../../../../../Middlewares/Third_Party/audio_modules/recognition/DNN/: weights_v1_80.h weights_v2_80.h
  group Middlewares/Third_Party/audio_modules/recognition/DNN/ActivationFunctions
    ../../../../../Middlewares/Third_Party/audio_modules/recognition/DNN/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu_q7.c
    ../../../../../MIDDLEWARES/THIRD_PARTY/AUDIO_MODULES/RECOGNITION/DNN/ACTIVATIONFUNCTIONS/: arm_relu_q15.c
  group Middlewares/Third_Party/audio_modules/recognition/DNN/ConvolutionFunctions
    ../../../../../Middlewares/Third_Party/audio_modules/recognition/DNN/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c
    ../../../../../MIDDLEWARES/THIRD_PARTY/AUDIO_MODULES/RECOGNITION/DNN/CONVOLUTIONFUNCTIONS/: arm_depthwise_separable_conv_HWC_q7.c
  group Middlewares/Third_Party/audio_modules/recognition/DNN/FullyConnectedFunctions
    ../../../../../Middlewares/Third_Party/audio_modules/recognition/DNN/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c
  group Middlewares/Third_Party/audio_modules/recognition/DNN/Include
    ../../../../../MIDDLEWARES/THIRD_PARTY/AUDIO_MODULES/RECOGNITION/DNN/Include/: arm_nn_tables.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group Middlewares/Third_Party/audio_modules/recognition/DNN/NNSupportFunctions
    ../../../../../MIDDLEWARES/THIRD_PARTY/AUDIO_MODULES/RECOGNITION/DNN/NNSUPPORTFUNCTIONS/: arm_nntables.c
    ../../../../../Middlewares/Third_Party/audio_modules/recognition/DNN/NNSupportFunctions/: arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
  group Middlewares/Third_Party/audio_modules/recognition/DNN/PoolingFunctions
    ../../../../../Middlewares/Third_Party/audio_modules/recognition/DNN/PoolingFunctions/: arm_pool_q7_HWC.c
  group Middlewares/Third_Party/audio_modules/recognition/DNN/SoftmaxFunctions
    ../../../../../Middlewares/Third_Party/audio_modules/recognition/DNN/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c
  group Middlewares/Third_Party/audio_modules/recognition/KWS
    ../../../../../MIDDLEWARES/THIRD_PARTY/AUDIO_MODULES/RECOGNITION/KWS/: kws.c kws.h
  group Middlewares/Third_Party/audio_modules/recognition/MFCC
    ../../../../../MIDDLEWARES/THIRD_PARTY/AUDIO_MODULES/RECOGNITION/MFCC/: mfcc.c mfcc.h
  group Middlewares/Third_Party/fatfs_disk
    ../../../../../Middlewares/Third_Party/fatfs_disk/: disk_mmc.c disk_mmc.h
  group Middlewares/Third_Party/ff13b
    ../../../../../MIDDLEWARES/THIRD_PARTY/ff13b/source/: diskio.c
    ../../../../../Middlewares/Third_Party/ff13b/source/: diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../MIDDLEWARES/THIRD_PARTY/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: portasm.s
  group Middlewares/Third_Party/HTTP2_LwIP/Config
    ../../../../../Middlewares/Third_Party/HTTP2_LWIP/Config/: FreeRTOSConfig.h http2_client_config.h http2_debug.h lwipopts.h
  group Middlewares/Third_Party/HTTP2_LwIP/Inc
    ../../../../../Middlewares/Third_Party/HTTP2_LWIP/Inc/: hpack.h http2_client.h http2_client_multipart.h http2_client_stream.h http2_common.h http2_compiler_port.h http2_debug.h http2_status.h
  group Middlewares/Third_Party/HTTP2_LwIP/Lib
    ../../../../../Middlewares/Third_Party/HTTP2_LWIP/Lib/: http2_lwip_CM7_wc32_ot.a
  group Middlewares/Third_Party/Jansson.2.10
    ../../../../../Middlewares/Third_Party/Jansson/: dump.c error_jansson.c hashtable.c hashtable_seed.c load.c memory.c pack_unpack.c strbuffer.c strconv.c utf.c value.c
  group Middlewares/Third_Party/LWIP/api
    ../../../../../Middlewares/Third_Party/LWIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Third_Party/LWIP/apps/sntp
    ../../../../../Middlewares/Third_Party/LWIP/src/apps/sntp/: sntp.c
  group Middlewares/Third_Party/LWIP/core
    ../../../../../Middlewares/Third_Party/LWIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Third_Party/LWIP/core/ipv4
    ../../../../../Middlewares/Third_Party/LWIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Third_Party/LWIP/netif
    ../../../../../Middlewares/Third_Party/LWIP/src/netif/: ethernet.c lowpan6.c
  group Middlewares/Third_Party/LWIP/system
    ../../../../../Middlewares/Third_Party/LWIP/system/OS/: sys_arch.c
  group Middlewares/Third_Party/mbedTLS
    ../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/Third_Party/wav
    ../../../../../Middlewares/Third_Party/wav/: util.c
    ../../../../../MIDDLEWARES/THIRD_PARTY/wav/: util.h wav_util.c wav_util.h
  group Utilities/TraceRecorder
    ../../../../../Utilities/TraceRecorder/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
