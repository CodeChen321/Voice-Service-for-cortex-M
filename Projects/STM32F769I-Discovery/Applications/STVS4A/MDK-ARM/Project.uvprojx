# Keil uVision project Project.uvprojx, settings and files
target STVS4A_BSP_LWIP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32_AVSdemo_F769 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG,AVS_USE_QSPI_FLASHED,AVS_USE_DEBUG,STM32F7,STM32F769xx,USE_HAL_DRIVER,USE_STM32F769I_DISCO,USE_STM32769I_DISCOVERY,xUSE_TRACEALYZER,xDATA_IN_ExtSDRAM,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,HAVE_STDINT_H
  c include: ../Inc;../Config;../../../../../Middlewares/ST/STVS4A/Src;../../../../../Middlewares/ST/STVS4A/Inc;../../../../../Middlewares/ST/STVS4A/Examples/Inc;../../../../../Middlewares/ST/STVS4A/Examples/Assets;../../../../../Middlewares/ST/STVS4A/Examples/Src/usb_audio_in;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32f7xx/Include;../../../../../Drivers/BSP;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Middlewares/Third_Party/Jansson;../../../../../Middlewares/Third_Party/HTTP2_LWIP/Inc;../../../../../Middlewares/Third_Party/HTTP2_LWIP/Config;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/inc;../../../../../Drivers/BSP/Components/wm8994;../../../../../Utilities/TraceRecorder/include;../../../../../Utilities/TraceRecorder/config;../../../../../Utilities/CPU ;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../../../../../Middlewares/Third_Party/LWIP/src/include;../../../../../Middlewares/Third_Party/LWIP/system;../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LwIP/Config;../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LwIP;../../../../../Middlewares/ST/STVS4A/Src/Porting/stm32F7xx/Bsp
  asm include: ../config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\STM32F769NIHx_FLASH_SDRAM.sct
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/Src
    ../Src/: system_stm32f7xx.c clean_lcd_swap_buffer.c platform_init.c main.c stm32f7xx_it.c usbd_conf_f7.c platform_adapt.c stm32f7xx_hal_timebase_tim.c esp_uart_conf.c ethernetif.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Middlewares/ST/STVS4A/Src
    ../../../../../Middlewares/ST/STVS4A/Src/: avs_core_imp.c avs_sdk_entry_imp.c avs_mem_imp.c avs_directive_imp.c avs_token_imp.c avs_json_formater_imp.c avs_state_imp.c avs_http2_imp.c avs_audio_imp.c
  group Middlewares/ST/STVS4A/Src/porting/common
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Common/: avs_sys_rng.c avs_spirit_mp3_decoder_imp.c avs_compiler_support.c
  group Middlewares/Third_Party/Jansson.2.10
    ../../../../../Middlewares/Third_Party/Jansson/: hashtable.c load.c memory.c utf.c dump.c error_jansson.c hashtable_seed.c strconv.c pack_unpack.c strbuffer.c value.c
  group Middlewares/ST/STVS4A/Examples/Services/AudioPlayer
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Services/: service_player.c service_audio_read_fs.c service_audio_play_mp3.c service_audio_read_https.c
  group Middlewares/ST/STVS4A/Examples/Tests
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Tests/: service_endurance_definition.c service_endurance_test.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c tasks.c croutine.c timers.c queue.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_mdios.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_spi.c stm32f7xx_hal_usart.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_jpeg.c stm32f7xx_ll_fmc.c stm32f7xx_hal_cec.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_rtc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rng.c stm32f7xx_hal_sram.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_lptim.c stm32f7xx_hal_cryp.c stm32f7xx_hal_i2s.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_nand.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_sdram.c stm32f7xx_hal_cortex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pcd.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_can.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dac.c stm32f7xx_hal_tim.c stm32f7xx_hal_nor.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_eth.c stm32f7xx_hal_uart.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_irda.c stm32f7xx_hal_crc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_adc.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_sai.c stm32f7xx_hal_smartcard_ex.c
  group Middlewares/Third_Party/mbedTLS
    ../../../../../Middlewares/Third_Party/mbedTLS/library/: ecdh.c pkcs5.c ssl_cache.c ctr_drbg.c hmac_drbg.c entropy.c pkparse.c md5.c platform.c ecp_curves.c x509_crl.c padlock.c version.c blowfish.c asn1parse.c md_wrap.c havege.c dhm.c ssl_ticket.c pk.c x509_crt.c x509_create.c x509write_csr.c x509_csr.c pkcs11.c ecjpake.c x509write_crt.c camellia.c cipher_wrap.c pem.c aes.c entropy_poll.c bignum.c des.c x509.c ssl_srv.c xtea.c asn1write.c memory_buffer_alloc.c base64.c sha256.c rsa.c ssl_tls.c md.c sha1.c md2.c oid.c pkwrite.c ssl_cli.c threading.c error.c ecp.c version_features.c pk_wrap.c sha512.c timing.c cmac.c ssl_ciphersuites.c certs.c pkcs12.c arc4.c ecdsa.c cipher.c ccm.c ripemd160.c ssl_cookie.c debug.c md4.c aesni.c gcm.c
  group Middlewares/MP3_Decoder
    ../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/lib/: lib_mp3decoder_cortex_m7_v2.1.0.a
  group Middlewares/ST/STVS4A/Src/porting
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/: avs_porting_imp.c
  group Middlewares/ST/STVS4A/Src/porting/Network/LwIP_eth
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LwIP/: avs_lwip_net_sockets.c avs_lwip_drv_network.c avs_lwip_network_imp.c avs_lwip_porting_imp.c avs_lwip_tls_imp.c
  group Middlewares/ST/STVS4A/Src/porting/Network/LwIP_esp
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LWIP_esp/: avs_lwip_drv_network.c avs_lwip_net_sockets.c avs_lwip_network_imp.c avs_lwip_porting_imp.c avs_lwip_tls_imp.c
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LWIP_esp/espDrv/: espDrvComUart.c espDrvCore.c espDrvEvents.c espDrvGlueAvs.c espDrvNetif.c espDrvOS.c
  group Middlewares/Third_Party/LWIP/core/ipv4
    ../../../../../Middlewares/Third_Party/LWIP/src/core/ipv4/: autoip.c etharp.c igmp.c icmp.c ip4_addr.c ip4_frag.c ip4.c dhcp.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
  group Middlewares/Third_Party/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_3.c
  group Middlewares/Third_Party/LWIP/api
    ../../../../../Middlewares/Third_Party/LWIP/src/api/: sockets.c netdb.c tcpip.c netbuf.c err.c netifapi.c api_lib.c api_msg.c
  group Middlewares/Third_Party/LWIP/core
    ../../../../../Middlewares/Third_Party/LWIP/src/core/: mem.c tcp_in.c pbuf.c udp.c inet_chksum.c init.c netif.c def.c tcp.c ip.c raw.c tcp_out.c dns.c stats.c memp.c timeouts.c sys.c
  group Middlewares/ST/STVS4A/Examples/Services
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/Services/: service_os.c service_wakeup.c service_alarm.c service_assets.c service_audio_feed_usb.c service_authentication.c service_serial_trace.c service_persistent_storage.c service_gui_page_info.c service_gui_page_language.c service_gui_page_test.c service_gui_resource_800_480.c service_gui_core.c service_gui_page_wifi.c service_gui_page_wifi_flash_esp.c
  group Middlewares/Third_Party/LWIP/netif
    ../../../../../Middlewares/Third_Party/LWIP/src/netif/: ethernet.c lowpan6.c
  group Middlewares/Third_Party/LWIP/system
    ../../../../../Middlewares/Third_Party/LWIP/system/OS/: sys_arch.c
  group Middlewares/ST/STVS4A/Examples/Usb_audio_in
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/usb_audio_in/: usbd_audio_ex.c usbd_desc.c usbd_audio_in.c
  group Drivers/BSP/STM327F769I_Discovery
    ../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery_qspi.c stm32f769i_discovery.c stm32f769i_discovery_sdram.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sd.c stm32f769i_discovery_ts.c stm32f769i_discovery_audio.c stm32f769i_discovery_eeprom.c
  group Middlewares/Third_Party/LWIP/apps/sntp
    ../../../../../Middlewares/Third_Party/LWIP/src/apps/sntp/: sntp.c
  group Middlewares/ST/STVS4A/Examples
    ../../../../../Middlewares/ST/STVS4A/Examples/Src/: avs.c
  group Middlewares/ST/STVS4A/Src/porting/stm32f7xx/bsp
    ../../../../../Middlewares/ST/STVS4A/Src/Porting/stm32F7xx/Bsp/: avs_porting_bsp_F7_audio_imp.c avs_porting_bsp_F7_sys.c avs_porting_bsp_F7.c avs_porting_bsp_F7_audio.c
  group Middlewares/Third_Party/HTTP2_LwIP/Lib
    ../../../../../Middlewares/Third_Party/HTTP2_LWIP/Lib/: http2_lwip_CM7_wc16_ot.a
  group Doc
    ../: readme.txt
target STVS4A_BSP_LWIP_ESP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: as above
  output: STM32_AVSdemo_F769 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CHECKSUM_BY_SOFTWARE,NDEBUG,AVS_USE_QSPI_FLASHED,AVS_USE_DEBUG,STM32F7,STM32F769xx,USE_HAL_DRIVER,USE_STM32F769I_DISCO,USE_STM32769I_DISCOVERY,xUSE_TRACEALYZER,xDATA_IN_ExtSDRAM,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,HAVE_STDINT_H
  c include: ../Inc;../Config;../../../../../Middlewares/ST/STVS4A/Src;../../../../../Middlewares/ST/STVS4A/Inc;../../../../../Middlewares/ST/STVS4A/Examples/Inc;../../../../../Middlewares/ST/STVS4A/Examples/Assets;../../../../../Middlewares/ST/STVS4A/Examples/Src/usb_audio_in;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32f7xx/Include;../../../../../Drivers/BSP;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Middlewares/Third_Party/Jansson;../../../../../Middlewares/Third_Party/HTTP2_LWIP/Inc;../../../../../Middlewares/Third_Party/HTTP2_LWIP/Config;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/ST/STM32_Audio/Codecs/SpiritDSP_MP3_Dec/inc;../../../../../Drivers/BSP/Components/wm8994;../../../../../Utilities/TraceRecorder/include;../../../../../Utilities/TraceRecorder/config;../../../../../Utilities/CPU;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../../../../../Middlewares/Third_Party/LWIP/src/include;../../../../../Middlewares/Third_Party/LWIP/system;../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LwIP_esp/Config;../../../../../Middlewares/ST/STVS4A/Src/Porting/Network/LwIP_esp;../../../../../Middlewares/ST/STVS4A/Src/Porting/stm32F7xx/Bsp;../../../../../Middlewares/ST/STVS4A/Src/Porting/stm32F7xx
  asm include: ../config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\STM32F769NIHx_FLASH_SDRAM.sct
software components: CMSIS:CORE 5.1.1
